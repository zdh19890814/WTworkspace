# IAR project ucos_lpc2148.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2148 NXP LPC2148
  ICCARM.CCDefines: FLASH
  ICCARM.CCIncludePath2: APP; bsp; uC-cpu; uCOS-II; uC-lib; uCOS-II/PORTS; uCOS-II/SOURCE
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: ucos_lpc2148.srec
  ILINK.IlinkOutputFile: ucos_lpc2148.out
  ILINK.IlinkIcfFile: BSP/LPC2148_FLASH.ICF
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    APP/: app.c app_cfg.h includes.h os_cfg.h
  group bsp
    BSP/: bsp.c bsp.h cstartup.s hardwares.c LPC2148_FLASH.ICF uart.c
  group uC/OS/PORT
    uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS/SOURSE
    uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
