# Keil uVision project Project.uvproj, settings and files
target Project (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\CoreSupport;..\User;..\Libraries\STM32_USB-FS-Device_Driver\inc;..\User\USB\USB_user\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\User\USB\USB_user\inc;..\SYSTEM\bds;..\SYSTEM\LED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group User
    ../User/: main.c stm32f10x_it.c stm32f10x_conf.h app_cfg.h wtp.c AT_app.c i2s_codec.c media_process.c wtp_mux.c tcpip.c
    ../SYSTEM/bds/: bds.c
    ../SYSTEM/LED/: led.c
  group CMSIS
    ../User/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c
  group USB-User
    ../User/USB/USB_user/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usbio.c
    ../User/USB/USB_user/inc/: usb_conf.h
  group USB-FS-Device_Driver
    ../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
    ../User/: platform_config.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group Readme
    ../: Readme.txt History.txt
